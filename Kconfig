## Kconfig
```kconfig
config HID_ACER
    tristate "Acer HID quirks"
    ---help---
      Help message of Synaptics
```
